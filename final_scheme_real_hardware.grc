options:
  parameters:
    generate_options: qt_gui
    id: test_oot_usrp
    output_language: python
    realtime_scheduling: '1'
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center frequency
    start: '0'
    step: 1e6
    stop: 6e9
    value: 773.1e6
  states: {}
- name: detect
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: fftSize
  id: variable
  parameters:
    value: int(32768/4)
  states: {}
- name: numSubbands
  id: variable_qtgui_entry
  parameters:
    label: Number of subbands
    type: int
    value: '16'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX gain (relative)
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15.36e6
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    comment: Threshold value relative to the dynamic range [max(dB)-min(dB)]
    label: Threshold (relative)
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.25'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: TX gain (relative)
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftSize
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fftSize
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftSize
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftSize)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: fftSize
    forward: 'False'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: fftSize
    name: '"Received spectrum"'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    name: '"Transmitted spectrum"'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"energyDetector output"'
    update_time: '0.001'
    vlen: fftSize
    x_start: '0'
    x_step: '1.0'
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: spectrumSharing_carrierAllocator_0
  id: spectrumSharing_carrierAllocator
  parameters:
    FFTSize: fftSize
    numSubbands: numSubbands
    seed: '0'
    txAmplitude: '1.0'
  states: {}
- name: spectrumSharing_energyDetector_0
  id: spectrumSharing_energyDetector
  parameters:
    FFTSize: fftSize
    numSubbands: numSubbands
    threshold: threshold
  states: {}
- name: spectrumSharing_scheduler_0
  id: spectrumSharing_scheduler
  parameters:
    off_ms: '1'
    on_ms: '9'
    sample_rate: samp_rate/fftSize
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: center_freq
    gain0: '20'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: center_freq
    gain0: rx_gain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_vector_to_stream_0, '0', uhd_usrp_sink_0, '0']
- [fft_vxx_0, '0', spectrumSharing_energyDetector_0, '0']
- [fft_vxx_1, '0', blocks_vector_to_stream_0, '0']
- [spectrumSharing_carrierAllocator_0, '0', fft_vxx_1, '0']
- [spectrumSharing_energyDetector_0, '0', qtgui_vector_sink_f_0, '0']
- [spectrumSharing_energyDetector_0, '0', spectrumSharing_carrierAllocator_0, '0']
- [spectrumSharing_scheduler_0, '0', spectrumSharing_carrierAllocator_0, '1']
- [spectrumSharing_scheduler_0, '0', spectrumSharing_energyDetector_0, '1']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
