options:
  parameters:
    generate_options: qt_gui
    id: test_oot
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha_len
  id: variable_qtgui_entry
  parameters:
    gui_hint: 4,2,1,1
    label: Number of alphas
    type: int
    value: '5'
  states: {}
- name: alpha_start
  id: variable_qtgui_entry
  parameters:
    gui_hint: 4,0,1,1
    label: Alpha start value
    type: real
    value: '0'
  states: {}
- name: alpha_stop
  id: variable_qtgui_entry
  parameters:
    gui_hint: 4,1,1,1
    label: Alpha stop value
    type: real
    value: '0.0002'
  states: {}
- name: alpha_vec
  id: variable
  parameters:
    value: np.linspace(alpha_start, alpha_stop, alpha_len)
  states: {}
- name: move_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,1,1,1
    label: Observation center frequency [Hz]
    type: int
    value: int(3e6)
  states: {}
- name: moved_BW
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,2,1,1
    label: Observation BW [Hz]
    type: int
    value: int(2e6)
  states: {}
- name: peak_alpha
  id: variable_qtgui_entry
  parameters:
    gui_hint: 6,1,1,1
    label: Observed alpha value
    type: real
    value: '0'
  states: {}
- name: peak_tau
  id: variable_qtgui_entry
  parameters:
    gui_hint: 6,0,1,1
    label: Observed tau value
    type: int
    value: '-128'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15.36e6
  states: {}
- name: tau_start
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,0,1,1
    label: Tau start value
    type: int
    value: '-130'
  states: {}
- name: tau_stop
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,1,1,1
    label: Tau stop value
    type: int
    value: '-124'
  states: {}
- name: tau_vec
  id: variable
  parameters:
    value: np.arange(tau_start, tau_stop)
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,3
    label: <b>Band pass filter settings</b>
    type: string
    value: ''
  states: {}
- name: variable_qtgui_label_0_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,0,1,3
    label: <b>Cyclic autocorrelation function tau and alpha vectors settings</b>
    type: string
    value: ''
  states: {}
- name: variable_qtgui_label_0_0_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 5,0,1,3
    label: <b>Selected tau and alpha value for metric calculation</b>
    type: string
    value: ''
  states: {}
- name: variable_qtgui_label_0_0_0_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 7,0,1,3
    label: <b>Received signal spectrum</b>
    type: string
    value: ''
  states: {}
- name: variable_qtgui_label_0_0_0_0_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 9,0,1,3
    label: <b>Cyclic autocorrelation function output</b>
    type: string
    value: ''
  states: {}
- name: variable_qtgui_label_0_0_0_0_0_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 11,0,1,3
    label: <b>Calculated metric for selected tau and alpha</b>
    type: string
    value: ''
  states: {}
- name: win_len
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0,1,1
    label: Window length [samples]
    type: int
    value: int(32001)
  states: {}
- name: CAF_metric
  id: qtgui_number_sink
  parameters:
    avg: '1'
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: ' '
    max: '10'
    type: float
    update_time: '0.010'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/martin/ownCloud/ESA_spectrum_sharing_makerspace/old_gnu/IQ_796e6MHz_samp-15.36Mhz.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: win_len
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: len(tau_vec)*len(alpha_vec)
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: move_freq
    decim: '8'
    samp_rate: samp_rate
    taps: ' firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*8), samp_rate/(2*8), moved_BW)'
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    gui_hint: 8,0,1,3
    type: complex
    update_time: '0.01'
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 10,0,1,3
    ncols: int(len(tau_vec))
    nrows: int(len(alpha_vec))
    samp_rate: samp_rate
    type: float
    update_time: '0.010'
    x_end_value: tau_vec[-1]
    x_label: '"Tau"'
    x_start_value: tau_vec[0]
    y_end_value: alpha_vec[-1]
    y_label: '"Alpha"'
    y_start_value: alpha_vec[0]
    zmax: '0.01'
    zmin: '0'
  states: {}
- name: spectrumSharing_CAF_0
  id: spectrumSharing_CAF
  parameters:
    alpha_vec: alpha_vec
    input_len: win_len
    peak_alpha: peak_alpha
    peak_tau: peak_tau
    tau_vec: tau_vec
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 15.36e6
    center_freq0: 796e6
    gain0: '60'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_stream_to_vector_0, '0', spectrumSharing_CAF_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_raster_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_stream_to_vector_0, '0']
- [spectrumSharing_CAF_0, '0', CAF_metric, '0']
- [spectrumSharing_CAF_0, '1', blocks_vector_to_stream_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
